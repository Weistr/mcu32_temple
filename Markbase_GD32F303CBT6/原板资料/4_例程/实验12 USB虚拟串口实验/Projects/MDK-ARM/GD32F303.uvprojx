# Keil uVision project GD32F303.uvprojx, settings and files
target USB_VSP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303CB GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F303 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F30X_HD
  c include: ..\..\Drivers\CMSIS\GD\GD32F30x\Include;..\..\Drivers\GD32F30x_standard_peripheral\Include;..\..\Drivers\CMSIS;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\sys;..\..\Drivers\SYSTEM\usart;..\..\User;..\..\Drivers\BSP\LED;..\..\Drivers\BSP\KEY;..\..\Middlewares\MALLOC;..\..\Middlewares\USB\CONFIG;..\..\Middlewares\USB\STM32_USB_Device_Library\Class\CDC\Inc;..\..\Middlewares\USB\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\USB\USB_HAL
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ../../Drivers/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group User
    ../../User/: main.c gd32f30x_it.c
    ../../Drivers/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/GD32F30x_peripheral
    ../../Drivers/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/USB_CORE
    ../../Middlewares/USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Middlewares/USB/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/USB_CONFIG
    ../../Middlewares/USB/CONFIG/: hw_config.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Middlewares/USB_HAL
    ../../Middlewares/USB/USB_HAL/: stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
